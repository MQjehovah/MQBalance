# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLib\include;..\User\include;..\Driver\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/Startup/: startup_stm32f10x_ld.s
  group FWLib
    ../FWLib/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group User
    ../User/: main.c stm32f10x_it.c delay.c
  group Driver
    ../Driver/: GPIO.c USART.c IIC.c MPU6050.c
